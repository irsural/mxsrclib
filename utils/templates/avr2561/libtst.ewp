# IAR project libtst.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 200
  General.SCRStackSize: 100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-ec-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 200
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.newCCIncludePaths: ..\mxsrclib\arch\cur\; ..\mxsrclib\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2561.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCNearHeapSize: 0x20
  ICCAVR.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: config.cpp config.h hard.h main.cpp mainprg.cpp mainprg.h
  group lib
    ../mxsrclib/: timer.cpp timer.h
  group lib/arch
    ../mxsrclib/arch/cur/: counter.cpp counter.h
